# IAR project RTC_PowerDown.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano103AE series Nuvoton Nano103AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\LCDLib\Include; ..\..\..\..\Library\Device\Nuvoton\Nano103\Include; ..\..\..\..\Library\StdDriver\Inc; ..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTC_PowerDown.bin
  ILINK.IlinkOutputFile: RTC_PowerDown.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/IAR/: startup_Nano103.s
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c retarget.c rtc.c sys.c uart.c
  group User
    ../: main.c
