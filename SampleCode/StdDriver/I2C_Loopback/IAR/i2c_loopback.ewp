# IAR project i2c_loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano103AE series Nuvoton Nano103AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano103\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c_loopback.bin
  ILINK.IlinkOutputFile: i2c_loopback.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/IAR/: startup_Nano103.s
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c
