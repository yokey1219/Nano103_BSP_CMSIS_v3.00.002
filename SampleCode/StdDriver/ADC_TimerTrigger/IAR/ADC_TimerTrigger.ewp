# IAR project ADC_TimerTrigger.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano103AE series Nuvoton Nano103AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano103\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: ADC_TimerTrigger.bin
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/IAR/: startup_Nano103.s
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
  group Libraries
    ../../../../Library/StdDriver/src/: adc.c clk.c pdma.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
